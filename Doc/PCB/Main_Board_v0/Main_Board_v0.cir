.title KiCad schematic
J1 GND +12V Conn_01x02
U1 +12V GND +5V 7805
C1 +12V GND C
C4 +5V GND C
U2 Net-_R2-Pad1_ Net-_C3-Pad1_ Net-_R1-Pad2_ Net-_R3-Pad2_ Net-_J3-Pad1_ NC_01 Net-_R6-Pad2_ GND Net-_C6-Pad1_ Net-_C5-Pad1_ Net-_R10-Pad2_ Net-_R9-Pad2_ Net-_R8-Pad2_ SCL SDA Net-_R7-Pad2_ NC_02 NC_03 GND +5V Net-_U2-Pad21_ Net-_U2-Pad22_ Net-_U2-Pad23_ Net-_U2-Pad24_ Net-_U2-Pad25_ Net-_U2-Pad26_ Net-_R4-Pad2_ NC_04 PIC18F23K20_ISS
R2 Net-_R2-Pad1_ +5V 10k
C6 Net-_C6-Pad1_ GND C
C5 Net-_C5-Pad1_ GND C
J3 Net-_J3-Pad1_ GND Conn_01x02_Male
J2 +5V Net-_C3-Pad1_ GND Conn_01x03_Male
C3 Net-_C3-Pad1_ GND C
C2 +5V GND C
C8 +5V GND C
C7 +12V GND C
U3 +5V GND Net-_RV1-Pad2_ Net-_U2-Pad24_ Net-_U2-Pad23_ Net-_U2-Pad22_ Net-_U2-Pad21_ Net-_U2-Pad25_ Net-_R5-Pad1_ GND Net-_U2-Pad26_ GND LCD
RV1 GND Net-_RV1-Pad2_ +5V 5k
R5 Net-_R5-Pad1_ +5V 100
R4 Net-_R11-Pad2_ Net-_R4-Pad2_ R
TP1 Net-_R11-Pad2_ GND TestPoint_2Pole
R1 Net-_Q1-Pad1_ Net-_R1-Pad2_ R
D1 +12V Net-_D1-Pad2_ 1N4001
J5 +12V Net-_D2-Pad2_ Screw_Terminal_01x02
R3 Net-_Q2-Pad1_ Net-_R3-Pad2_ R
D2 +12V Net-_D2-Pad2_ 1N4001
TP2 Net-_R10-Pad2_ GND TestPoint_2Pole
TP3 Net-_R9-Pad2_ GND TestPoint_2Pole
TP4 Net-_R8-Pad2_ GND TestPoint_2Pole
TP5 Net-_R7-Pad2_ GND TestPoint_2Pole
TP6 Net-_R6-Pad2_ GND TestPoint_2Pole
R6 +5V Net-_R6-Pad2_ 10k
R7 +5V Net-_R7-Pad2_ 10k
R8 +5V Net-_R8-Pad2_ 10k
R9 +5V Net-_R9-Pad2_ 10k
R10 +5V Net-_R10-Pad2_ 10k
R11 +5V Net-_R11-Pad2_ 10k
Y1 Net-_C5-Pad1_ Net-_C6-Pad1_ Crystal
J4 +12V Net-_D1-Pad2_ Screw_Terminal_01x02
Q1 Net-_Q1-Pad1_ Net-_D1-Pad2_ GND IRLZ34N
Q2 Net-_Q2-Pad1_ Net-_D2-Pad2_ GND IRLZ34N
J6 GND +12V Conn_01x02
U4 +12V GND +5V 7805
C9 +12V GND C
C12 +5V GND C
U5 Net-_R13-Pad1_ Net-_C11-Pad1_ Net-_R12-Pad2_ Net-_R14-Pad2_ Net-_J8-Pad1_ NC_05 Net-_R17-Pad2_ GND Net-_C14-Pad1_ Net-_C13-Pad1_ Net-_R21-Pad2_ Net-_R20-Pad2_ Net-_R19-Pad2_ SCL SDA Net-_R18-Pad2_ NC_06 NC_07 GND +5V Net-_U5-Pad21_ Net-_U5-Pad22_ Net-_U5-Pad23_ Net-_U5-Pad24_ Net-_U5-Pad25_ Net-_U5-Pad26_ Net-_R15-Pad2_ NC_08 PIC18F23K20_ISS
R13 Net-_R13-Pad1_ +5V 10k
C14 Net-_C14-Pad1_ GND C
C13 Net-_C13-Pad1_ GND C
J8 Net-_J8-Pad1_ GND Conn_01x02_Male
J7 +5V Net-_C11-Pad1_ GND Conn_01x03_Male
C11 Net-_C11-Pad1_ GND C
C10 +5V GND C
C16 +5V GND C
C15 +12V GND C
U6 +5V GND Net-_RV2-Pad2_ Net-_U5-Pad24_ Net-_U5-Pad23_ Net-_U5-Pad22_ Net-_U5-Pad21_ Net-_U5-Pad25_ Net-_R16-Pad1_ GND Net-_U5-Pad26_ GND LCD
RV2 GND Net-_RV2-Pad2_ +5V 5k
R16 Net-_R16-Pad1_ +5V 100
R15 Net-_R15-Pad1_ Net-_R15-Pad2_ R
TP7 Net-_R15-Pad1_ GND TestPoint_2Pole
R12 Net-_Q3-Pad1_ Net-_R12-Pad2_ R
D3 +12V Net-_D3-Pad2_ 1N4001
J10 +12V Net-_D4-Pad2_ Screw_Terminal_01x02
R14 Net-_Q4-Pad1_ Net-_R14-Pad2_ R
D4 +12V Net-_D4-Pad2_ 1N4001
TP8 Net-_R21-Pad2_ GND TestPoint_2Pole
TP9 Net-_R20-Pad2_ GND TestPoint_2Pole
TP10 Net-_R19-Pad2_ GND TestPoint_2Pole
TP11 Net-_R18-Pad2_ GND TestPoint_2Pole
TP12 Net-_R17-Pad2_ GND TestPoint_2Pole
R17 +5V Net-_R17-Pad2_ 10k
R18 +5V Net-_R18-Pad2_ 10k
R19 +5V Net-_R19-Pad2_ 10k
R20 +5V Net-_R20-Pad2_ 10k
R21 +5V Net-_R21-Pad2_ 10k
R22 +5V Net-_R15-Pad1_ 10k
Y2 Net-_C13-Pad1_ Net-_C14-Pad1_ Crystal
J9 +12V Net-_D3-Pad2_ Screw_Terminal_01x02
Q3 Net-_Q3-Pad1_ Net-_D3-Pad2_ GND IRLZ34N
Q4 Net-_Q4-Pad1_ Net-_D4-Pad2_ GND IRLZ34N
.end
